# Keil uVision project SmartCar.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartCar +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Start;.\Library;.\User;.\HARDWARE;.\System;.\SYSTEM\sys;.\HARDWARE\LED;.\HARDWARE\MOTOR;.\HARDWARE\TIME;.\HARDWARE\OLED;.\HARDWARE\USART;.\HARDWARE\Servo;.\HARDWARE\HCSR04;.\HARDWARE\Trace
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_dma.c misc.c
  group System
    ./SYSTEM/: Delay.c Delay.h
    ./SYSTEM/sys/: sys.c sys.h
  group User
    ./USER/: main.c control.c control.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group HARDWARE
    ./HARDWARE/LED/: LED.c LED.h
    ./HARDWARE/MOTOR/: MOTOR.c MOTOR.h
    ./HARDWARE/TIME/: TIM3_PWM.c TIM3_PWM.h
    ./HARDWARE/HCSR04/: HCSR04.c HCSR04.h
    ./HARDWARE/Servo/: Servo.c Servo.h
    ./HARDWARE/Trace/: Trace.c Trace.h
    ./HARDWARE/OLED/: OLED.c OLED.h OLEDIIC.c OLEDIIC.h word.c word.h
    ./HARDWARE/USART/: USART1.c USART1.h
